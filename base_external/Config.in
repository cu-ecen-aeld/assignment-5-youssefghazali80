## base_external/Config.in
```kconfig
menu "External Packages"

    source "$BR2_EXTERNAL_base_external_PATH/package/aesd-assignments/Config.in"


endmenu
```
